# Keil uVision project zigbee_offline_programmer.uvprojx, settings and files
target application (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zigbee_offline_programmer +hex
  AfterMake: fromelf --bin --output .\OUTPUT\zigbee_offline_programmer.bin .\OUTPUT\zigbee_offline_programmer.axf
  AfterMake: .\..\..\Download\copy_bin.bat
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\Libraries\Mass_Storage\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_USB-FS-Device_Driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group MassStorage
    ../../Libraries/Mass_Storage/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group BSP
    ../../User/BSP/: bsp_usart.c
    ../../User/bsp/: bsp_iwdg.c bsp_systick.c bsp_spi.c bsp_button.c bsp_timer.c bsp_nxp.c bsp_buzzer.c
  group SYS
    ../../User/sys/: sys_command_line.c sys_queue.c sys_scheduler.c
  group cm_backtrace
    ../../User/component/cm_backtrace/: cm_backtrace.c
    ../../User/component/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Util
    ../../User/component/util/: util.c
  group FatFS
    ../../User/component/fatfs/: diskio.c ff.c
    ../../User/component/fatfs/option/: ccsbcs.c
  group LittleFS
    ../../User/component/littlefs/: lfs_util.c lfs.c
  group Button
    ../../User/component/button/: button.c
  group APP
    ../../User/app/: app_mass_storage.c app_fatfs.c app_button.c app_database.c app_nxp.c app_buzzer.c
  group User
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
